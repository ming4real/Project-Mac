SUMMARY = "Linux image for the MacBook Pro 14,3 internal SSD"
DESCRIPTION = "A Yocto Project Linux distribution for repurposed Intel Macs"
LICENSE = "MIT"

require mac-image-common.inc
