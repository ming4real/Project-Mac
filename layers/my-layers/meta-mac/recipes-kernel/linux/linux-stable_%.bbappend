FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:macbookpro14-3 = " file://macbook-display.cfg"

