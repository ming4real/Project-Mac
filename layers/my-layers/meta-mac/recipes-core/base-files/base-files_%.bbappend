# Pick up the local copy of the files in this layer first
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

