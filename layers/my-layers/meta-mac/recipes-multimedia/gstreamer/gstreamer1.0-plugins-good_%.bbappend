PACKAGECONFIG:append = " vpx"

